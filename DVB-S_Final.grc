options:
  parameters:
    author: quique
    generate_options: qt_gui
    id: dvbs_final
    output_language: python
    title: DVB-S Simulation
  states: {}

blocks:
- name: FreqOff
  id: variable_qtgui_range
  parameters:
    label: Frequency Offset
    orient: Qt.Horizontal
    start: '-0.1'
    step: '0.001'
    stop: '0.1'
    value: '0'
  states: {}
- name: Noise
  id: variable_qtgui_range
  parameters:
    label: Channel Noise
    orient: Qt.Horizontal
    start: '0'
    step: '0.01'
    stop: '1'
    value: '0'
  states: {}
- name: SampSymb
  id: variable
  parameters:
    comment: CM - PCS
    value: '4'
  states: {}
- name: delay
  id: variable_qtgui_range
  parameters:
    label: Delay
    orient: Qt.Horizontal
    start: '0'
    step: '1'
    stop: '100'
    value: '0'
  states: {}
- name: nfilts
  id: variable
  parameters:
    comment: PCS
    value: '100'
  states: {}
- name: qpsk_const
  id: variable_constellation_rect
  parameters:
    comment: CM
    const_points: '[-1-1j, -1+1j, 1+1j, 1-1j]'
    imag_sect: '2'
    real_sect: '2'
    rot_sym: '4'
    sym_map: '[0, 1, 2, 3]'
    w_imag_sect: '1'
    w_real_sect: '1'
  states: {}
- name: rrc_taps_0
  id: variable
  parameters:
    comment: PCS
    value: firdes.root_raised_cosine(nfilts, nfilts, 1.0/float(SampSymb), 0.35, 45*nfilts)
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 55e6
  states: {}
- name: Vector_Source_1
  id: blocks_vector_source_x
  parameters:
    repeat: 'True'
    type: byte
    vector: (71,0,0,0,0,0,115,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,71,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0)
  states: {state: disabled}
- name: Video_Source
  id: blocks_file_source
  parameters:
    comment: |-
      Sourcing .ts file which
      was converted from
      a .mov file using VLC
    file: /home/quique/Documents/PSK-Simulation/DVB_Codification/DVB_Codification/Test_Video.ts
    repeat: 'False'
    type: byte
  states: {state: disabled}
- name: Video_Source_0
  id: blocks_file_source
  parameters:
    comment: |-
      Sourcing .ts file which
      was converted from
      a .mov file using VLC
    file: /home/enriquec/video.ts
    repeat: 'False'
    type: byte
  states: {}
- name: blocks_delay_0
  id: blocks_delay
  parameters:
    delay: delay
    type: float
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: /home/enriquec/video_received.ts
    type: byte
  states: {}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: byte
  states: {}
- name: blocks_repack_bits_bb_0
  id: blocks_repack_bits_bb
  parameters:
    endianness: gr.GR_LSB_FIRST
    k: '2'
    l: '8'
  states: {}
- name: blocks_skiphead_0
  id: blocks_skiphead
  parameters:
    num_items: '8'
    type: byte
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: byte
  states: {}
- name: blocks_uchar_to_float_0
  id: blocks_uchar_to_float
  parameters: {}
  states: {}
- name: blocks_uchar_to_float_0_0
  id: blocks_uchar_to_float
  parameters: {}
  states: {}
- name: blocks_uchar_to_float_0_1
  id: blocks_uchar_to_float
  parameters: {}
  states: {state: disabled}
- name: blocks_uchar_to_float_0_1_0
  id: blocks_uchar_to_float
  parameters: {}
  states: {state: disabled}
- name: blocks_udp_sink_0
  id: blocks_udp_sink
  parameters:
    eof: 'True'
    ipaddr: 127.0.0.1
    port: '4321'
    psize: '1316'
    type: byte
    vlen: '1'
  states: {state: disabled}
- name: blocks_udp_source_0
  id: blocks_udp_source
  parameters:
    eof: 'True'
    ipaddr: 127.0.0.1
    port: '5004'
    psize: '1316'
    type: byte
    vlen: '1'
  states: {state: disabled}
- name: blocks_vector_to_stream_0
  id: blocks_vector_to_stream
  parameters:
    num_items: '6048'
    type: byte
  states: {}
- name: blocks_vector_to_stream_1
  id: blocks_vector_to_stream
  parameters:
    num_items: '1504'
    type: byte
  states: {state: disabled}
- name: channels_channel_model_0
  id: channels_channel_model
  parameters:
    epsilon: '1.0'
    freq_offset: FreqOff
    noise_voltage: Noise
    seed: '0'
    taps: 1.0 + 1.0j
  states: {}
- name: digital_cma_equalizer_cc_0
  id: digital_cma_equalizer_cc
  parameters:
    modulus: '1'
    mu: '.01'
    num_taps: '15'
    sps: '2'
  states: {}
- name: digital_constellation_decoder_cb_0
  id: digital_constellation_decoder_cb
  parameters:
    constellation: qpsk_const
  states: {}
- name: digital_constellation_modulator_0
  id: digital_constellation_modulator
  parameters:
    constellation: qpsk_const
    differential: 'True'
    excess_bw: '0.35'
    samples_per_symbol: SampSymb
  states: {}
- name: digital_costas_loop_cc_0
  id: digital_costas_loop_cc
  parameters:
    order: '4'
    w: '.1'
  states: {}
- name: digital_diff_decoder_bb_0
  id: digital_diff_decoder_bb
  parameters:
    modulus: '4'
  states: {}
- name: digital_pfb_clock_sync_xxx_0
  id: digital_pfb_clock_sync_xxx
  parameters:
    filter_size: nfilts
    init_phase: nfilts/2
    loop_bw: '0.1'
    max_dev: '1.5'
    osps: '2'
    sps: SampSymb
    taps: rrc_taps_0
    type: ccf
  states: {}
- name: dtv_dvbt_convolutional_deinterleaver_0
  id: dtv_dvbt_convolutional_deinterleaver
  parameters:
    I: '12'
    M: '17'
    blocks: '136'
  states: {}
- name: dtv_dvbt_convolutional_interleaver_0
  id: dtv_dvbt_convolutional_interleaver
  parameters:
    I: '12'
    M: '17'
    blocks: '136'
  states: {}
- name: dtv_dvbt_energy_descramble_0
  id: dtv_dvbt_energy_descramble
  parameters:
    nsize: '8'
  states: {}
- name: dtv_dvbt_energy_dispersal_0
  id: dtv_dvbt_energy_dispersal
  parameters:
    nsize: '1'
  states: {}
- name: dtv_dvbt_inner_coder_0
  id: dtv_dvbt_inner_coder
  parameters:
    code_rate: C7_8
    constellation: qpsk
    hierarchy: nh
    ninput: '1'
    noutput: '6048'
  states: {}
- name: dtv_dvbt_reed_solomon_dec_0
  id: dtv_dvbt_reed_solomon_dec
  parameters:
    blocks: '8'
    gfpoly: '0x11d'
    k: '239'
    m: '8'
    n: '255'
    p: '2'
    s: '51'
    t: '8'
  states: {}
- name: dtv_dvbt_reed_solomon_enc_0
  id: dtv_dvbt_reed_solomon_enc
  parameters:
    blocks: '8'
    gfpoly: '0x11d'
    k: '239'
    m: '8'
    n: '255'
    p: '2'
    s: '51'
    t: '8'
  states: {}
- name: dtv_dvbt_viterbi_decoder_0
  id: dtv_dvbt_viterbi_decoder
  parameters:
    block_size: '6048'
    code_rate: C7_8
    constellation: qpsk
    hierarchy: nh
    type: b
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    grid: 'True'
    label1: RX
    label2: TX
    nconnections: '2'
    size: '1024'
    srate: samp_rate
    type: float
  states: {}
- name: qtgui_time_sink_x_2
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    name: '"Input Energy Dispersal"'
    size: '1024'
    srate: samp_rate
    type: float
    ylabel: Byte Value
  states: {state: disabled}
- name: qtgui_time_sink_x_2_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    name: '"Output Energy Dispersal"'
    size: '1024'
    srate: samp_rate
    type: float
    ylabel: Byte Value
  states: {state: disabled}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: coder-modulator
  states: {}
- name: virtual_sink_1
  id: virtual_sink
  parameters:
    stream_id: constellation-demodulator
  states: {}
- name: virtual_sink_2
  id: virtual_sink
  parameters:
    stream_id: demodulator-decoder
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: coder-modulator
  states: {}
- name: virtual_source_1
  id: virtual_source
  parameters:
    stream_id: constellation-demodulator
  states: {}
- name: virtual_source_2
  id: virtual_source
  parameters:
    stream_id: demodulator-decoder
  states: {}

connections:
- [Vector_Source_1, '0', blocks_throttle_0, '0']
- [Video_Source, '0', blocks_throttle_0, '0']
- [Video_Source_0, '0', blocks_throttle_0, '0']
- [blocks_delay_0, '0', qtgui_time_sink_x_0, '1']
- [blocks_repack_bits_bb_0, '0', blocks_skiphead_0, '0']
- [blocks_skiphead_0, '0', virtual_sink_2, '0']
- [blocks_throttle_0, '0', blocks_uchar_to_float_0_0, '0']
- [blocks_throttle_0, '0', blocks_uchar_to_float_0_1, '0']
- [blocks_throttle_0, '0', dtv_dvbt_energy_dispersal_0, '0']
- [blocks_uchar_to_float_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_uchar_to_float_0_0, '0', blocks_delay_0, '0']
- [blocks_uchar_to_float_0_1, '0', qtgui_time_sink_x_2, '0']
- [blocks_uchar_to_float_0_1_0, '0', qtgui_time_sink_x_2_0, '0']
- [blocks_udp_source_0, '0', blocks_throttle_0, '0']
- [blocks_vector_to_stream_0, '0', virtual_sink_0, '0']
- [blocks_vector_to_stream_1, '0', blocks_uchar_to_float_0_1_0, '0']
- [channels_channel_model_0, '0', digital_pfb_clock_sync_xxx_0, '0']
- [digital_cma_equalizer_cc_0, '0', digital_costas_loop_cc_0, '0']
- [digital_constellation_decoder_cb_0, '0', digital_diff_decoder_bb_0, '0']
- [digital_constellation_modulator_0, '0', channels_channel_model_0, '0']
- [digital_costas_loop_cc_0, '0', virtual_sink_1, '0']
- [digital_diff_decoder_bb_0, '0', blocks_repack_bits_bb_0, '0']
- [digital_pfb_clock_sync_xxx_0, '0', digital_cma_equalizer_cc_0, '0']
- [dtv_dvbt_convolutional_deinterleaver_0, '0', dtv_dvbt_reed_solomon_dec_0, '0']
- [dtv_dvbt_convolutional_interleaver_0, '0', dtv_dvbt_inner_coder_0, '0']
- [dtv_dvbt_energy_descramble_0, '0', blocks_file_sink_0, '0']
- [dtv_dvbt_energy_descramble_0, '0', blocks_null_sink_0, '0']
- [dtv_dvbt_energy_descramble_0, '0', blocks_uchar_to_float_0, '0']
- [dtv_dvbt_energy_descramble_0, '0', blocks_udp_sink_0, '0']
- [dtv_dvbt_energy_dispersal_0, '0', blocks_vector_to_stream_1, '0']
- [dtv_dvbt_energy_dispersal_0, '0', dtv_dvbt_reed_solomon_enc_0, '0']
- [dtv_dvbt_inner_coder_0, '0', blocks_vector_to_stream_0, '0']
- [dtv_dvbt_reed_solomon_dec_0, '0', dtv_dvbt_energy_descramble_0, '0']
- [dtv_dvbt_reed_solomon_enc_0, '0', dtv_dvbt_convolutional_interleaver_0, '0']
- [dtv_dvbt_viterbi_decoder_0, '0', dtv_dvbt_convolutional_deinterleaver_0, '0']
- [virtual_source_0, '0', digital_constellation_modulator_0, '0']
- [virtual_source_1, '0', digital_constellation_decoder_cb_0, '0']
- [virtual_source_2, '0', dtv_dvbt_viterbi_decoder_0, '0']

metadata:
  file_format: 1
